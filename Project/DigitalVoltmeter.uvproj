# Keil uVision project DigitalVoltmeter.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DigitalVoltmeter +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Common\INC;..\USER\INC
  group MAIN
    ../MAIN/: main.asm
  group USER
    ../USER/INC/: SYS_INT.asm USER_Function.asm
  group Common
    ../Common/INC/: Function.asm
  group DOC
    ../DOC/: Readme.txt
